options:
  parameters:
    category: Custom
    generate_options: hb
    id: tigr_transmit_control
    output_language: python
    title: TIGR Transmit Control
  states: {}

blocks:
- name: interleaver
  id: variable
  parameters:
    value: trellis.interleaver(2000,666)
  states: {}
- name: training_data
  id: variable
  parameters:
    value: default_block_header(subcarriers,fft_length,fbmc,estimation_preamble,[])
  states: {}
- name: whitener_pn
  id: variable
  parameters:
    value: '[randint(0,1) for i in range(used_id_bits*repeated_id_bits)]'
  states: {}
- name: Import
  id: import
  parameters:
    imports: import math, numpy, copy
  states: {}
- name: blks2_selector_0
  id: blks2_selector
  parameters:
    input_index: coding
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: 2*40
    type: byte
    vlen: subcarriers
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '40'
    type: float
    vlen: subcarriers
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1]+[0]*(data_blocks/2-1)'
  states: {}
- name: coding
  id: parameter
  parameters:
    label: coding
    value: '1'
  states: {}
- name: data_blocks
  id: parameter
  parameters:
    label: data_blocks
    value: '10'
  states: {}
- name: estimation_preamble
  id: parameter
  parameters:
    label: estimation_preamble
    value: '0'
  states: {}
- name: fbmc
  id: parameter
  parameters:
    label: fbmc
    value: '1'
  states: {}
- name: fft_length
  id: parameter
  parameters:
    label: fft_length
    value: '256'
  states: {}
- name: filter_length
  id: parameter
  parameters:
    label: filter_length
    value: '4'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from random import seed,randint, getrandbits
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import trellis
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from ofdm.preambles_grc import default_block_header
  states: {}
- name: ofdm_allocation_src_0
  id: ofdm_allocation_src
  parameters:
    address: '"tcp://*:3333"'
    coding: '1'
    data_symbols: data_blocks
    subcarriers: subcarriers
  states: {}
- name: ofdm_ber_reference_source_0
  id: ofdm_ber_reference_source
  parameters:
    data_blocks: data_blocks
    subcarriers: subcarriers
  states: {}
- name: ofdm_generic_mapper_bcv_0
  id: ofdm_generic_mapper_bcv
  parameters:
    coding: '1'
    frame_size: data_blocks
    vlen: subcarriers
  states: {}
- name: ofdm_multiply_frame_fc_0
  id: ofdm_multiply_frame_fc
  parameters:
    frame_size: data_blocks
    subc: subcarriers
  states: {}
- name: ofdm_puncture_bb_1
  id: ofdm_puncture_bb
  parameters:
    vlen: subcarriers
  states: {}
- name: ofdm_repetition_encoder_sb_0
  id: ofdm_repetition_encoder_sb
  parameters:
    input_bits: used_id_bits
    repetitions: repeated_id_bits
    whitener: whitener_pn
  states: {}
- name: ofdm_stream_controlled_mux_b_0
  id: ofdm_stream_controlled_mux_b
  parameters: {}
  states: {}
- name: ofdm_tx_mux_ctrl_0
  id: ofdm_tx_mux_ctrl
  parameters:
    subcarriers: subcarriers
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
    vlen: subcarriers
  states: {}
- name: repeated_id_bits
  id: parameter
  parameters:
    label: repeated_id_bits
    value: '26'
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: subcarriers
    value: '208'
  states: {}
- name: trellis_encoder_xx_0
  id: trellis_encoder_xx
  parameters:
    fsm_args: trellis.fsm(1,2,[91,121])
    init_state: '0'
    type: bb
  states: {}
- name: trellis_permutation_0
  id: trellis_permutation
  parameters:
    interleaver_size: interleaver.K()
    syms_per_block: '1'
    table: interleaver.INTER()
    type: byte
  states: {}
- name: used_id_bits
  id: parameter
  parameters:
    label: used_id_bits
    value: '8'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://*:4444"'
    timeout: '100'
    type: float
    vlen: subcarriers
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://*:4445"'
    timeout: '100'
    type: byte
    vlen: subcarriers
  states: {}

connections:
- [blks2_selector_0, '0', ofdm_stream_controlled_mux_b_0, '2']
- [blocks_keep_one_in_n_0, '0', zeromq_pub_sink_1, '0']
- [blocks_keep_one_in_n_1, '0', zeromq_pub_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', ofdm_puncture_bb_1, '0']
- [blocks_vector_source_x_0, '0', ofdm_puncture_bb_1, '2']
- [ofdm_allocation_src_0, '0', ofdm_ber_reference_source_0, '0']
- [ofdm_allocation_src_0, '0', ofdm_repetition_encoder_sb_0, '0']
- [ofdm_allocation_src_0, '1', ofdm_ber_reference_source_0, '1']
- [ofdm_allocation_src_0, '2', blocks_keep_one_in_n_0, '0']
- [ofdm_allocation_src_0, '2', ofdm_generic_mapper_bcv_0, '1']
- [ofdm_allocation_src_0, '2', ofdm_puncture_bb_1, '1']
- [ofdm_allocation_src_0, '3', blocks_keep_one_in_n_1, '0']
- [ofdm_allocation_src_0, '3', ofdm_multiply_frame_fc_0, '1']
- [ofdm_allocation_src_0, '4', ofdm_tx_mux_ctrl_0, '0']
- [ofdm_ber_reference_source_0, '0', blks2_selector_0, '1']
- [ofdm_ber_reference_source_0, '0', trellis_encoder_xx_0, '0']
- [ofdm_generic_mapper_bcv_0, '0', ofdm_multiply_frame_fc_0, '0']
- [ofdm_multiply_frame_fc_0, '0', pad_sink_0, '0']
- [ofdm_puncture_bb_1, '0', trellis_permutation_0, '0']
- [ofdm_repetition_encoder_sb_0, '0', ofdm_stream_controlled_mux_b_0, '1']
- [ofdm_stream_controlled_mux_b_0, '0', ofdm_generic_mapper_bcv_0, '0']
- [ofdm_tx_mux_ctrl_0, '0', ofdm_stream_controlled_mux_b_0, '0']
- [trellis_encoder_xx_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [trellis_permutation_0, '0', blks2_selector_0, '0']

metadata:
  file_format: 1
