options:
  parameters:
    category: Custom
    generate_options: hb
    id: tigr_fbmc_inner_receiver
    output_language: python
    title: TIGR_FBMC_Inner_Receiver
  states: {}

blocks:
- name: pd_lookahead
  id: variable
  parameters:
    value: 2*fft_length
  states: {}
- name: pd_threshold
  id: variable
  parameters:
    value: '0.4'
  states: {}
- name: Import
  id: import
  parameters:
    imports: import math, numpy, copy
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int((frame_length-10)*fft_length/2 - fft_length/4 -1)
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '7'
    type: byte
  states: {}
- name: blocks_keep_one_in_n_1_0
  id: blocks_keep_one_in_n
  parameters:
    n: frame_length
    type: complex
    vlen: subcarriers
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '6'
    type: complex
    vlen: '208'
  states: {}
- name: blocks_skiphead_1
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: complex
    vlen: subcarriers
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2'
    type: complex
    vlen: '128'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1]+[0]*(frame_length-1)'
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1]+[0]*(frame_length-1)'
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_length
    type: complex
  states: {}
- name: data_blocks
  id: parameter
  parameters:
    label: data_blocks
    value: '10'
  states: {}
- name: disable_freq_sync
  id: parameter
  parameters:
    label: disable_freq_sync
    value: '0'
  states: {}
- name: estimation_preamble
  id: parameter
  parameters:
    label: estimation_preamble
    value: '0'
  states: {}
- name: fft_length
  id: parameter
  parameters:
    label: fft_length
    value: '256'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: filter_length
  id: parameter
  parameters:
    label: filter_length
    value: '4'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1./fft_length]*fft_length'
    type: fff
  states: {}
- name: frame_length
  id: parameter
  parameters:
    label: frame_length
    value: '30'
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from ofdm.preambles_grc import default_block_header
  states: {}
- name: ofdm_fbmc_beta_multiplier_vcvc_0
  id: ofdm_fbmc_beta_multiplier_vcvc
  parameters:
    K: filter_length
    M: fft_length
    lp: filter_length*fft_length-1
    offset: '0'
  states: {}
- name: ofdm_fbmc_junction_vcvc_0
  id: ofdm_fbmc_junction_vcvc
  parameters:
    M: fft_length
    num_input: '2'
  states: {}
- name: ofdm_fbmc_oqam_postprocessing_vcvc_0
  id: ofdm_fbmc_oqam_postprocessing_vcvc
  parameters:
    M: subcarriers
    offset: '0'
    theta_sel: '0'
  states: {}
- name: ofdm_fbmc_overlapping_serial_to_parallel_cvc_0
  id: ofdm_fbmc_overlapping_serial_to_parallel_cvc
  parameters:
    M: fft_length
  states: {}
- name: ofdm_fbmc_polyphase_network_vcvc_2
  id: ofdm_fbmc_polyphase_network_vcvc
  parameters:
    K: filter_length
    M: fft_length
    lp: fft_length*filter_length-1
    reverse: 'True'
  states: {}
- name: ofdm_fbmc_polyphase_network_vcvc_3
  id: ofdm_fbmc_polyphase_network_vcvc
  parameters:
    K: filter_length
    M: fft_length
    lp: fft_length*filter_length-1
    reverse: 'True'
  states: {}
- name: ofdm_fbmc_postprocess_CTF_estimate_0
  id: ofdm_fbmc_postprocess_CTF_estimate
  parameters:
    vlen: subcarriers
  states: {}
- name: ofdm_fbmc_separate_vcvc_0
  id: ofdm_fbmc_separate_vcvc
  parameters:
    M: fft_length
    num_output: '2'
  states: {}
- name: ofdm_fbmc_subchannel_processing_vcvc_0
  id: ofdm_fbmc_subchannel_processing_vcvc
  parameters:
    M: subcarriers
    extra_pad: '1'
    sel_eq: '0'
    sel_preamble: '1'
    syms_per_frame: data_blocks+1
    zero_pads: '2'
  states: {}
- name: ofdm_frequency_shift_vcc_0
  id: ofdm_frequency_shift_vcc
  parameters:
    cp_length: '0'
    sensitivity: '-1.0/fft_length'
    vlen: fft_length
  states: {}
- name: ofdm_lms_fir_ff_0
  id: ofdm_lms_fir_ff
  parameters:
    len: '20'
    mu: '0.001'
  states: {}
- name: ofdm_mm_frequency_estimator_0
  id: ofdm_mm_frequency_estimator
  parameters:
    identical_parts: '4'
    scale: '2'
    vlen: int(fft_length/2)
  states: {}
- name: ofdm_peak_detector_02_fb_0
  id: ofdm_peak_detector_02_fb
  parameters:
    look_ahead: pd_lookahead
    threshold: pd_threshold
  states: {}
- name: ofdm_recursive_timing_metric_0
  id: ofdm_recursive_timing_metric
  parameters:
    fft_length: 2*fft_length
  states: {}
- name: ofdm_vector_mask_0
  id: ofdm_vector_mask
  parameters:
    cut_left: (fft_length-subcarriers)/2
    mask: '[]'
    mask_len: subcarriers
    vlen: fft_length
  states: {}
- name: ofdm_vector_sampler_0
  id: ofdm_vector_sampler
  parameters:
    itemsize: '1'
    type: complex
    vlen: int(fft_length/2*frame_length)
  states: {}
- name: ofdm_vector_sampler_0_0
  id: ofdm_vector_sampler
  parameters:
    itemsize: int(fft_length/2)
    type: complex
    vlen: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: subcarriers
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    type: complex
    vlen: subcarriers
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: subcarriers
    value: '208'
  states: {}

connections:
- [blocks_delay_0, '0', ofdm_vector_sampler_0, '1']
- [blocks_delay_0_0, '0', ofdm_vector_sampler_0_0, '1']
- [blocks_keep_one_in_n_1_0, '0', ofdm_fbmc_postprocess_CTF_estimate_0, '0']
- [blocks_skiphead_0, '0', ofdm_fbmc_subchannel_processing_vcvc_0, '0']
- [blocks_skiphead_1, '0', ofdm_fbmc_oqam_postprocessing_vcvc_0, '0']
- [blocks_stream_to_vector_0, '0', ofdm_frequency_shift_vcc_0, '0']
- [blocks_vector_source_x_0, '0', blocks_delay_0_0, '0']
- [blocks_vector_source_x_0_1, '0', ofdm_frequency_shift_vcc_0, '2']
- [blocks_vector_to_stream_0_0, '0', ofdm_fbmc_overlapping_serial_to_parallel_cvc_0, '0']
- [fft_vxx_0, '0', ofdm_fbmc_beta_multiplier_vcvc_0, '0']
- [fir_filter_xxx_0, '0', ofdm_peak_detector_02_fb_0, '0']
- [ofdm_fbmc_beta_multiplier_vcvc_0, '0', ofdm_vector_mask_0, '0']
- [ofdm_fbmc_junction_vcvc_0, '0', fft_vxx_0, '0']
- [ofdm_fbmc_oqam_postprocessing_vcvc_0, '0', pad_sink_2, '0']
- [ofdm_fbmc_overlapping_serial_to_parallel_cvc_0, '0', ofdm_fbmc_separate_vcvc_0, '0']
- [ofdm_fbmc_polyphase_network_vcvc_2, '0', ofdm_fbmc_junction_vcvc_0, '0']
- [ofdm_fbmc_polyphase_network_vcvc_3, '0', ofdm_fbmc_junction_vcvc_0, '1']
- [ofdm_fbmc_postprocess_CTF_estimate_0, '0', pad_sink_0, '0']
- [ofdm_fbmc_separate_vcvc_0, '0', ofdm_fbmc_polyphase_network_vcvc_2, '0']
- [ofdm_fbmc_separate_vcvc_0, '1', ofdm_fbmc_polyphase_network_vcvc_3, '0']
- [ofdm_fbmc_subchannel_processing_vcvc_0, '0', blocks_skiphead_1, '0']
- [ofdm_fbmc_subchannel_processing_vcvc_0, '1', blocks_keep_one_in_n_1_0, '0']
- [ofdm_frequency_shift_vcc_0, '0', blocks_vector_to_stream_0_0, '0']
- [ofdm_lms_fir_ff_0, '0', ofdm_frequency_shift_vcc_0, '1']
- [ofdm_mm_frequency_estimator_0, '0', ofdm_lms_fir_ff_0, '0']
- [ofdm_peak_detector_02_fb_0, '0', blocks_delay_0, '0']
- [ofdm_recursive_timing_metric_0, '0', fir_filter_xxx_0, '0']
- [ofdm_vector_mask_0, '0', blocks_skiphead_0, '0']
- [ofdm_vector_sampler_0, '0', blocks_stream_to_vector_0, '0']
- [ofdm_vector_sampler_0_0, '0', ofdm_mm_frequency_estimator_0, '0']
- [pad_source_0, '0', ofdm_recursive_timing_metric_0, '0']
- [pad_source_0, '0', ofdm_vector_sampler_0, '0']

metadata:
  file_format: 1
